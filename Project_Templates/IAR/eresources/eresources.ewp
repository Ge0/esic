# IAR project eresources.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: eresources.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/esic/eresources/: raster_font_factory.h raster_font_header.h raster_font_table.h raster_font_table_header.h raster_icon.h raster_icon_factory.h raster_icon_header.h
  group src
    ../../../eresources/src/: raster_font.c raster_font_factory.c raster_font_table.c raster_icon.c raster_icon_factory.c raster_icon_header.c
