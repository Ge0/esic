# IAR project etools.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: etools.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/esic/etools/: container.h hashnode.h hashtable.h list.h map.h vector.h zstring.h zstring_buffer.h
  group src
    ../../../etools/src/: container.c hashnode.c hashtable.c list.c map.c vector.c zstring.c zstring_buffer.c
