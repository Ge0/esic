# IAR project egraphics.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: egraphics.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OPEN1788
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/esic/egraphics/: ellipse.h geometrical_renderer.h painter.h pixel.h rectangle.h renderer.h shape.h shape_ptr.h triangle.h vertice.h
  group includes/factories
    ../../../includes/esic/egraphics/factories/: painters_factory.h
  group src
    ../../../egraphics/src/: ellipse.c geometrical_renderer.c painter.c pixel.c rectangle.c shape_ptr.c triangle.c vertice.c
  group src/factories
    ../../../egraphics/src/factories/: painters_factory.c
