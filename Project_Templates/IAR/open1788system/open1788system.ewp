# IAR project open1788system.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788; __LPC177X_8X__; USB_CAN_BE_DEVICE
  ICCARM.CCIncludePath2: ..\..\..\open1788\Core\CM3\CoreSupport; ..\..\..\open1788\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\open1788\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\open1788\Drivers\include; ..\..\..\open1788\BoardSupport; ..\..\..\includes; ..\..\..\open1788\User\fatfs\includes; ..\..\..\open1788\User\includes; ..\..\..\open1788\User\MassStorageDevice; ..\..\..\open1788\User\MassStorageDevice\Lib; ..\..\..\open1788\LPCUSBLib\Drivers\USB
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: open1788system.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS-CM3
    ../../../open1788/Core/CM3/CoreSupport/: core_cm3.c
    ../../../open1788/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Drivers/includes
    ../../../open1788/Drivers/include/: debug_frmwrk.h lpc177x_8x_clkpwr.h lpc177x_8x_gpdma.h lpc177x_8x_libcfg_default.h lpc177x_8x_mci.h lpc177x_8x_pinsel.h lpc177x_8x_rtc.h lpc177x_8x_uart.h
  group Drivers/src
    ../../../open1788/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_gpdma.c lpc177x_8x_mci.c lpc177x_8x_pinsel.c lpc177x_8x_rtc.c lpc177x_8x_uart.c
  group Startup
    ../../../open1788/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/iar/: startup_LPC177x_8x.s
  group User/fatfs/includes
    ../../../open1788/User/fatfs/includes/: diskio.h ff.h ffconf.h fs_mci.h integer.h
  group User/fatfs/src
    ../../../open1788/User/fatfs/src/: ff.c fs_mci.c
  group User/fatfs/src/option
    ../../../open1788/User/fatfs/src/option/: ccsbcs.c
  group User/includes
    ../../../open1788/User/includes/: debug_module.h EX_SDRAM.h fat_module.h monitor.h system_queue.h timer.h
    ../../../includes/esic/elcd/: open1788_lcd.h
    ../../../includes/esic/eapi/: open1788_system.h
  group User/MassStorageDevice
    ../../../open1788/MassStorageDevice/Lib/: DataRam.c DataRam.h SCSI.c SCSI.h
    ../../../open1788/MassStorageDevice/: Descriptors.c Descriptors.h MassStorage.c MassStorage.h
  group User/src
    ../../../open1788/User/src/: debug_module.c EX_SDRAM.c fat_module.c fattime.c monitor.c open1788_lcd.c open1788_system.c system_queue.c timer.c uart_irq.c
  group User/src/IAR
    ../../../open1788/User/src/IAR/: time_impl.s
