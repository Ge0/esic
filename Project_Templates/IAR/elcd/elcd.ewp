# IAR project elcd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: elcd.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/esic/elcd/: emulator_lcd.h lcd.h lcd_painter.h
  group src
    ../../../elcd/src/: lcd.c lcd_painter.c
