# IAR project libsic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libsic.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OPEN1788
  ICCARM.CCOptLevel: 3
  group includes/marking
    ../../../includes/libsic/marking/: increment_marking_variable.h marking_file.h marking_font_tt.h marking_line.h marking_variable.h text_marking_line.h text_marking_variable.h
  group src/marking
    ../../../libsic/src/marking/: marking_font_tt.c text_marking_line.c
