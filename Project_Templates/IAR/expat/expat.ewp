# IAR project expat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; $WS_DIR$/../../includes/expat
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: expat.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/expat/: amigaconfig.h ascii.h asciitab.h expat.h expat_external.h iasciitab.h internal.h latin1tab.h macconfig.h nametab.h utf8tab.h watcomconfig.h winconfig.h xmlrole.h xmltok.h xmltok_impl.h
  group src
    ../../../expat/src/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
