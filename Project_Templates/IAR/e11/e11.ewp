# IAR project e11.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1778 NXP LPC1778
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: e11.hex
  ILINK.IlinkOutputFile: e11.out
  ILINK.IlinkIcfFile: $WS_DIR$\config\LPC1788_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 3
  group includes
    ../../../e11/includes/: e11_ui.h xml_ui_factory.h
  group includes/factories
    ../../../e11/includes/factories/: marking_file_v5_factory.h marking_font_tt_factory.h xml_ui_factory.h
  group includes/ui
    ../../../e11/includes/ui/: dotpen_ui.h main_ui.h
  group lib
    ../eapi/Debug/Exe/: eapi.a
    ../egui/Debug/Exe/: egui.a
    ../elcd/Debug/Exe/: elcd.a
    ../eresources/Debug/Exe/: eresources.a
    ../etools/Debug/Exe/: etools.a
    ../expat/Debug/Exe/: expat.a
    ../lpcusblib_device/: LPCUSBlib_LPC177x_8x_Device.a
    ../open1788system/Debug/Exe/: open1788system.a
  group src
    ../../../e11/src/: e11.c e11_ui.c main.c
  group src/factories
    ../../../e11/src/factories/: marking_file_v5_factory.c marking_font_tt_factory.c xml_ui_factory.c
  group src/ui
    ../../../e11/src/ui/: dotpen_ui.c main_ui.c
