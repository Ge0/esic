# IAR project egui.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: OPEN1788
  ICCARM.CCIncludePath2: $WS_DIR$/../../includes; ../../../e11/includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: egui.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group includes
    ../../../includes/esic/egui/: abstract_widget_renderer.h checkbox.h default_widget_renderer.h label.h picture.h textbox.h widget.h widget_ptr.h
  group src
    ../../../egui/src/: checkbox.c default_widget_renderer.c label.c picture.c textbox.c widget.c widget_ptr.c
